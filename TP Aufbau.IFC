Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: TP Aufbau.IFC
Time: 2021-10-06T11:03:06
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: TP Blende BIM_TP Blende außen
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 204.94

# IfcBuildingElementProxy: TP Gehäuse BIM_898115200 TP Gehäuse
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 607.15; Version 1: 0 - Edelstahl; Version 2: 1 - pulverbeschichtet weiß RAL 9016; Version 3: 2 - Gehäuse silbergrau RAL 9006; Version 4: 3 - X - Sonderfarbe

# IfcBuildingElementProxy: TP LED Befestigung BIM_898115216 TP Befestigung Linse
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 240.41; Version 1: A- 1*LED Flächen Linse, Mh max 4m; Version 2: B- 1*LED Wege Linse, Mh max 4m; Version 3: F- 2LED m. Flächen Linse, Mh max. 8m; Version 4: W- 2LED m. Wege Linse, Mh max. 8m; Version 5: Z- 6LED klar Abd. Fläche, Mh max12m

# IfcBuildingElementProxy: TP Montagefläche BIM_TP Montagefäche Aufbau
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: TP Scheibe BIM_898115220 TP Scheibe
In: Default Storey
Material: PC
SolidWorks Custom Properties - Material: PC; Gewicht: 78.84

# IfcBuildingElementProxy: TP Technik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AM3 - AT DS & BS, LFP 3,2V 3h 2/4W; Version 2: AX3 - AT.DS & BS, LFP 3,2V 3h ca. 140Lm; Version 3: AX8 - AT.DS & BS, LFP 3,2V 8h ca. 140Lm; Version 4: C - zentr. Vers. AC/DC Adressmodul; Version 5: E - für zentrale Versorgung AC/DC; Version 6: FM3 - AT.DS&BS, LFP3,2V 3h 2-6W RC250; Version 7: FM8 - AT.DS&BS, LFP3,2V 8h 2-6W RC250

# IfcElementAssembly: TP Aufbau
In: Default Storey
SolidWorks Custom Properties - Version 1: 4 - Schutzart IP 42; Version 2: 7 - Schutzart IP65
PSet_Mass_Property - Mass Measure: 1.21758; Area Measure: 0.592531 m2; Volume Measure: 0.000286573 m3
